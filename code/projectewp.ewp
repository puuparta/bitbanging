# IAR project projectewp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120E5QR TexasInstruments LM4F120E5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.2\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.2\arm\CMSIS\Include; C:\TI-CMSIS-Devices-8636\TI\LM4F\Include
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.c main.c
  group documents
    ../documents/: lm4f120h5qr-124014.pdf spmu289c.pdf
  group include
    include/: interrupt.h leds.h switches.h timers.h
    ../../../../../../TI-CMSIS-Devices-8636/TI/LM4F/Include/: LM4F120E5QR.h
    include/LM4F/: system_LM4F.h
